Commit message: updated odometry

File: robot_task1/urdf/rob_desc.urdf (robot description, URDF)
Before this commit: robot three_wheel_robot, 5 links, 4 joints
Joints:
- joint base_joint: origin xyz=0 0 0.1 rpy=0 0 0 -> xyz=0.5 0.5 0.0 rpy=0 0 1.57
